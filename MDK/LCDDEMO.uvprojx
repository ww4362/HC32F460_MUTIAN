# Keil uVision project LCDDEMO.uvprojx, settings and files
target LCDDEMO_Debug (6240000::V6.24::ARMCLANG)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IROM1(0x0,0x80000) IROM2(0x3000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: LCDDEMO +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,
  c include: .\common;.\source;.\driver\inc;..\Hardware;..\middlewares\lvgl;..\middlewares\lvgl\src;..\middlewares\lvgl\examples\porting;..\middlewares\lvgl\examples\;..\middlewares;..\middlewares\lvgl\demos;..\middlewares\lvgl\demos\widgets;..\eez\src\ui;..\eezfolw\src\ui;.\source\eez\src\ui;.\source\FreeRTOS-Kernel\include;.\source\FreeRTOS-Kernel\portable;.\source\FreeRTOS-Kernel;.\source\SH367303;..\Hardware\sh_367303;..\Hardware\sw6306
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: 说明.txt
  group source
    ./source/: main.c printf.c printf.h
  group driver
    ./driver/src/: hc32_ll.c hc32_ll_icg.c hc32_ll_utility.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_efm.c hc32_ll_clk.c hc32_ll_gpio.c hc32_ll_fcg.c hc32_ll_aos.c hc32_ll_cmp.c hc32_ll_interrupts.c hc32f460_ll_interrupts_share.c hc32_ll_tmra.c hc32_ll_spi.c hc32_ll_tmr0.c hc32_ll_dma.c hc32_ll_usart.c hc32_ll_tmr6.c hc32_ll_i2c.c
  group Hardware
    ../Hardware/: LCD.c LCD.h lcd_init.c lcd_init.h lcdfont.h pic.h multi_button.c multi_button.h
    ../Hardware/sh_367303/: IIC.c IIC.h flash.c flash.h
    ../Hardware/sw6306/: sw6306.c sw6306.h sw6306_IIC.c sw6306_IIC.h
  group txt
    ./: 说明文本.txt
  group eez
    ./source/eez/src/ui/: actions.h fonts.h images.c images.h screens.c screens.h structs.h styles.c styles.h ui.c ui.h vars.h ui_font_5x9.c ui_font_rajdhani_bold.c ui_font_rajdhani_bold_14.c ui_font_rajdhani_medium_20.c ui_font_7px_1.c ui_font_16px.c
  group RTOS/include
    ./source/FreeRTOS-Kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group RTOS/port
    ./source/FreeRTOS-Kernel/portable/: heap_4.c port.c
  group RTOS
    ./source/FreeRTOS-Kernel/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c RTOS_mian.c RTOS_mian.h stream_buffer.c tasks.c timers.c
  group SH367303
    ../Hardware/sh_367303/: BMS.c BMS.h BMS_UART.c BMS_UART.h CRC.c CRC.h README.md SH367303.c SH367303.h
target LCDDEMO_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: as above
  output: LCDDEMO +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F460,USE_DDL_DRIVER,
  c include: .\common;.\source;.\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0, LVGL:Display 9.2.2, LVGL:Essential 9.2.2, LVGL:Porting:Display 9.2.2, LVGL:Porting:Input 9.2.2
